# Keil uVision project Moebius.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Moebius +hex
  c flags: Optim=2 v6Lang=4 v6LangP=7 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS;.\Public;.\HardWare\KEY;.\HardWare\LED;.\HardWare\BlueTooth;.\HardWare\OLED;.\HardWare\ENCODER;.\HardWare\ADC;.\HardWare\BALANCE\CONTROL;.\HardWare\BALANCE\DataScope_DP;.\HardWare\BALANCE\DMP;.\HardWare\BALANCE\filter;.\HardWare\BALANCE\MPU6050;.\HardWare\BALANCE\show;.\HardWare\IIC;.\HardWare\EXTI;.\HardWare\MOTOR;.\HardWare\PS2;.\HardWare\SPI;.\HardWare\USARTX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./User/: Moebius.c config.h
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group HardWare
    ./HardWare/MOTOR/: motor.c
    ./HardWare/ENCODER/: encoder.c
    ./HardWare/ADC/: adc.c
    ./HardWare/BALANCE/filter/: filter.c
    ./HardWare/BALANCE/show/: show.c
    ./HardWare/BALANCE/CONTROL/: control.c
    ./HardWare/EXTI/: exti.c
    ./HardWare/PS2/: pstwo.c
    ./HardWare/BlueTooth/: BlueTooth.c
    ./HardWare/LED/: LED.C
    ./HardWare/KEY/: key.c
    ./HardWare/IIC/: IOI2C.c
    ./HardWare/BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./HardWare/BALANCE/MPU6050/: MPU6050.c
    ./HardWare/SPI/: spi.c
    ./HardWare/USARTX/: usartx.c
  group Public
    ./Public/: Sys.c Systick.c USART.c Sys.h
    ./User/: define.h
